
IMAGE_FEATURES += " ssh-server-openssl"
